# Keil uVision project OV2640.uvprojx, settings and files
target OV7670 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: OV2640 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\DCMI;..\HARDWARE\OV2640;..\HARDWARE\TIMER;..\HARDWARE\USART2;..\FWLIB\inc;..\USER;..\M8266WIFI;..\HARDWARE\LED;..\HARDWARE\OV7725;..\HARDWARE\MOTOR;..\HARDWARE\CAN
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/DCMI/: dcmi.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/OV7725/: ov7725.c sccb.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/CAN/: can.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_dcmi.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_dma.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_spi.c stm32f4xx_can.c
  group README
    ../: readme.txt
  group M8266WIFI
    ../M8266WIFI/: M8266HostIf_STM32xx.c M8266WIFI_ops.c test_m8266wifi.c M8266WIFIDrv_STM32F4xx.a brd_cfg.h
    ./: M8266WIFI_set.c M8266WIFI_set.h
